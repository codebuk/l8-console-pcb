File: sensor.kicad_sch (KiCad schematic)
At the start: 17 parts, among them Q1 AO3400A, U4 ST_SENSOR_2, U5 IIS3DHHCTR

Commit message: update to version 9 on selwyn
Other:
- title: (none) -> l8
